# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\FREERTOS\include;..\FREERTOS\port;..\HARDWARE\DHT;..\HARDWARE\KEY;..\HARDWARE\RTC;..\HARDWARE\IWDG;..\HARDWARE\BEEP;..\HARDWARE\SFM;..\HARDWARE\USARTLCD;..\HARDWARE\MOTOR;..\HARDWARE\MFRC522;..\HARDWARE\W25QXX;..\HARDWARE\KEYBOARD;..\HARDWARE\IIC;..\HARDWARE\AT24C02;..\HARDWARE\MQTT;..\HARDWARE\FLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT/: dht11.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SFM/: sfm.c
    ../HARDWARE/USARTLCD/: usart6.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/MFRC522/: mfrc522.c
    ../HARDWARE/w25qxx/: w25qxx.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/IIC/: i2c.c
    ../HARDWARE/AT24C02/: at24c02.c
    ../HARDWARE/MQTT/: esp8266.c esp8266_mqtt.c
    ../HARDWARE/FLASH/: flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_flash.c
  group FreeRTOS_CORE
    ../FREERTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/heap/: heap_4.c
    ../FREERTOS/port/: port.c
